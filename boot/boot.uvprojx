# Keil uVision project boot.uvprojx, settings and files
target boot (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_CONFIG_LOCAL
  c include: .\Src;.\User;..\gwbase\Libraries\CMSIS;..\gwbase\Libraries\STM32F4xx_HAL_Driver\Inc;..\gwbase\bsp;..\gwbase\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\boot.sct
  group boot
    ./Src/: main.c boot_uart.c boot_uart.h app_jump.c app_jump.h ota_flag.c ota_flag.h drv_spiflash.c drv_spiflash.h fw_image.c fw_image.h fw_install.c fw_install.h
  group User
    ./User/: system_stm32f4xx.c stm32f4xx_hal_conf.h
  group Public
    ./../gwbase/Public/: system.c system.h
  group CMSIS
    ./../gwbase/Libraries/CMSIS/: startup_stm32f407xx.s
  group HAL
    ./../gwbase/Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c
